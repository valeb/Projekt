# Keil uVision project PDA_Test_RC522.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PDA_Test_RC522 +hex
  c flags: wLevel=1
  c include: ..\system;..\system\COMMON_FILES;..\modules\rc522
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: STM32F10x.s
  group user
    ./: main.c
  group system
    ../system/: SYS.H SYS.C
  group modules
    ../modules/rc522/: rc522.c
