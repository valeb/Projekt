# Keil uVision project project.uvproj, settings and files
target FLASH (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=1
  c include: .\cm3;.\library\inc;.\library\src;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group start
    ./cm3/startup/: startup_stm32f10x_hd.s
  group lib
    ./library/src/: Retarget.c misc.c
  group user
    ./: project.c
    ./user/: Init_SYS.c rc522.c Lcd_ILI9320.c
  group Read me
    ./user/: readme.txt
target RAM (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: project +hex
  c flags: Optim=1
  c define: VECT_TAB_RAM
  c include: .\cm3;.\library\inc;.\library\src;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0xc000
  memory RVCT9: RAM 0x2000c000 size 0x4000
