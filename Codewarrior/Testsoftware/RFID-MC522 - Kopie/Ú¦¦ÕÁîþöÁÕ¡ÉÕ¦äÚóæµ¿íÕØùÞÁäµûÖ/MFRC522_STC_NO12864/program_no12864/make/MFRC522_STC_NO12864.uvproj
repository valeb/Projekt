# Keil uVision project MFRC522_STC_NO12864.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F32XE STC11F32XE Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: MFRC522_STC_NO12864 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../: key.c main.c rc522.c include.h rc522.h
